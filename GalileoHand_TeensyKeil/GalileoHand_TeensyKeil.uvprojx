# Keil uVision project GalileoHand_TeensyKeil.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: MK20DX256xxx7 NXP
  pack: Keil.Kinetis_K20_DFP.1.5.2
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x1FFF8000,0x8000) IROM(0x00000000,0x40000) IROM2(0x10000000,0x8000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: GalileoHand_TeensyKeil +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group Source
    ./: main.c
  group Drivers
    ./: drivers.c drivers.h finger.c finger.h
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1, Data Exchange:JSON:Jansson 2.7.0, Device:Startup 1.0.0
